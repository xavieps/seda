# Keil uVision project TP_Simple.uvprojx, settings and files
target MiniDK2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TP_Simple
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\Libraries\CM3\CoreSupport;..\Libraries\CM3\DeviceSupport;..\Libraries\GLCD;..\Libraries\TouchPanel;..\USER;..\Libraries\LPC1700CMSIS_Firmware_Library\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\obj\TP_Simple.sct
  group StartUp
    ../Libraries/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CM3/DeviceSupport/: startup_LPC17xx.s system_LPC17xx.c
  group GLCD
    ../Libraries/GLCD/: AsciiLib.c GLCD.c
  group TouchPanel
    ../Libraries/TouchPanel/: TouchPanel.c
  group New Group
    ../USER/GIEC/: tp_simple.c
target simulacion (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: as above
  output: TP_Simple
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\obj\TP_Simple.sct
software components: CMSIS:CORE 5.6.0
